SRC_URI += "file://defconfig"
KBUILD_DEFCONFIG:machine = ""